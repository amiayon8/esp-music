#include "font_engine.hpp"
#include <cstring>

static const uint8_t BasicFont5x7[95][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x5F, 0x00, 0x00},
    {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7F, 0x14, 0x7F, 0x14},
    {0x24, 0x2A, 0x7F, 0x2A, 0x12},
    {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50},
    {0x00, 0x05, 0x03, 0x00, 0x00},
    {0x00, 0x1C, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1C, 0x00},
    {0x14, 0x08, 0x3E, 0x08, 0x14},
    {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00},
    {0x08, 0x08, 0x08, 0x08, 0x08},
    {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02},
    {0x3E, 0x51, 0x49, 0x45, 0x3E},
    {0x00, 0x42, 0x7F, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46},
    {0x21, 0x41, 0x45, 0x4B, 0x31},
    {0x18, 0x14, 0x12, 0x7F, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3C, 0x4A, 0x49, 0x49, 0x30},
    {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36},
    {0x06, 0x49, 0x49, 0x29, 0x1E},
    {0x00, 0x36, 0x36, 0x00, 0x00},
    {0x00, 0x56, 0x36, 0x00, 0x00},
    {0x08, 0x14, 0x22, 0x41, 0x00},
    {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x00, 0x41, 0x22, 0x14, 0x08},
    {0x02, 0x01, 0x51, 0x09, 0x06},
    {0x32, 0x49, 0x79, 0x41, 0x3E},
    {0x7E, 0x11, 0x11, 0x11, 0x7E},
    {0x7F, 0x49, 0x49, 0x49, 0x36},
    {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C},
    {0x7F, 0x49, 0x49, 0x49, 0x41},
    {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A},
    {0x7F, 0x08, 0x08, 0x08, 0x7F},
    {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01},
    {0x7F, 0x08, 0x14, 0x22, 0x41},
    {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    {0x7F, 0x04, 0x08, 0x10, 0x7F},
    {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06},
    {0x3E, 0x41, 0x51, 0x21, 0x5E},
    {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31},
    {0x01, 0x01, 0x7F, 0x01, 0x01},
    {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F},
    {0x3F, 0x40, 0x38, 0x40, 0x3F},
    {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07},
    {0x61, 0x51, 0x49, 0x45, 0x43},
    {0x00, 0x7F, 0x41, 0x41, 0x00},
    {0x02, 0x04, 0x08, 0x10, 0x20},
    {0x00, 0x41, 0x41, 0x7F, 0x00},
    {0x04, 0x02, 0x01, 0x02, 0x04},
    {0x40, 0x40, 0x40, 0x40, 0x40},
    {0x00, 0x01, 0x02, 0x04, 0x00},
    {0x20, 0x54, 0x54, 0x54, 0x78},
    {0x7F, 0x48, 0x44, 0x44, 0x38},
    {0x38, 0x44, 0x44, 0x44, 0x20},
    {0x38, 0x44, 0x44, 0x48, 0x7F},
    {0x38, 0x54, 0x54, 0x54, 0x18},
    {0x08, 0x7E, 0x09, 0x01, 0x02},
    {0x0C, 0x52, 0x52, 0x52, 0x3E},
    {0x7F, 0x08, 0x04, 0x04, 0x78},
    {0x00, 0x44, 0x7D, 0x40, 0x00},
    {0x20, 0x40, 0x44, 0x3D, 0x00},
    {0x7F, 0x10, 0x28, 0x44, 0x00},
    {0x00, 0x41, 0x7F, 0x40, 0x00},
    {0x7C, 0x04, 0x18, 0x04, 0x78},
    {0x7C, 0x08, 0x04, 0x04, 0x78},
    {0x38, 0x44, 0x44, 0x44, 0x38},
    {0x7C, 0x14, 0x14, 0x14, 0x08},
    {0x08, 0x14, 0x14, 0x18, 0x7C},
    {0x7C, 0x08, 0x04, 0x04, 0x08},
    {0x48, 0x54, 0x54, 0x54, 0x20},
    {0x04, 0x3F, 0x44, 0x40, 0x20},
    {0x3C, 0x40, 0x40, 0x20, 0x7C},
    {0x1C, 0x20, 0x40, 0x20, 0x1C},
    {0x3C, 0x40, 0x30, 0x40, 0x3C},
    {0x44, 0x28, 0x10, 0x28, 0x44},
    {0x0C, 0x50, 0x50, 0x50, 0x3C},
    {0x44, 0x64, 0x54, 0x4C, 0x44},
    {0x00, 0x08, 0x36, 0x41, 0x00},
    {0x00, 0x00, 0x7F, 0x00, 0x00},
    {0x00, 0x41, 0x36, 0x08, 0x00},
    {0x10, 0x08, 0x08, 0x10, 0x08}
};

int16_t FontEngine::getFontHeight(FontSize size) {
    switch (size) {
        case FontSize::Small:
            return 8;
        case FontSize::Medium:
            return 14;
        case FontSize::Large:
            return 18;
        case FontSize::Title:
            return 22;
        default:
            return 12;
    }
}

int16_t FontEngine::drawCharacter(EPaperCanvas& canvas, int16_t x, int16_t y, char character, FontSize size, CanvasColor color) {
    if (character < 32 || character > 126) {
        character = ' ';
    }

    const uint8_t* glyphColumns = BasicFont5x7[character - 32];
    uint8_t scale = 1;
    if (size == FontSize::Medium) {
        scale = 2;
    } else if (size == FontSize::Large) {
        scale = 2;
    } else if (size == FontSize::Title) {
        scale = 3;
    }

    for (uint8_t col = 0; col < 5; ++col) {
        uint8_t columnBits = glyphColumns[col];
        for (uint8_t row = 0; row < 7; ++row) {
            if ((columnBits & (1 << row)) != 0) {
                if (scale == 1) {
                    canvas.setPixel(x + col, y + row, color);
                } else {
                    canvas.fillRectangle(x + col * scale, y + row * scale, scale, scale, color);
                }
            }
        }
    }

    int16_t advance = (5 * scale) + (size == FontSize::Small ? 1 : 2);
    return advance;
}

int16_t FontEngine::drawString(EPaperCanvas& canvas, int16_t x, int16_t y, const char* text, FontSize size, CanvasColor color) {
    if (text == nullptr) {
        return 0;
    }

    int16_t currentX = x;
    size_t length = std::strlen(text);
    for (size_t index = 0; index < length; ++index) {
        int16_t advance = drawCharacter(canvas, currentX, y, text[index], size, color);
        currentX += advance;
    }

    return currentX - x;
}

int16_t FontEngine::drawStringTruncated(EPaperCanvas& canvas, int16_t x, int16_t y, const char* text, int16_t maxWidth, FontSize size, CanvasColor color) {
    if (text == nullptr || maxWidth <= 0) {
        return 0;
    }

    int16_t ellipsisWidth = measureStringWidth("...", size);
    int16_t currentX = x;
    size_t length = std::strlen(text);

    int16_t totalWidth = measureStringWidth(text, size);
    if (totalWidth <= maxWidth) {
        return drawString(canvas, x, y, text, size, color);
    }

    int16_t availableWidth = maxWidth - ellipsisWidth;
    for (size_t index = 0; index < length; ++index) {
        int16_t charWidth = (size == FontSize::Small) ? 6 : (size == FontSize::Title ? 17 : 12);
        if ((currentX - x) + charWidth > availableWidth) {
            drawString(canvas, currentX, y, "...", size, color);
            currentX += ellipsisWidth;
            break;
        }
        int16_t advance = drawCharacter(canvas, currentX, y, text[index], size, color);
        currentX += advance;
    }

    return currentX - x;
}

int16_t FontEngine::measureStringWidth(const char* text, FontSize size) {
    if (text == nullptr) {
        return 0;
    }

    size_t length = std::strlen(text);
    int16_t charAdvance = 6;
    if (size == FontSize::Medium || size == FontSize::Large) {
        charAdvance = 12;
    } else if (size == FontSize::Title) {
        charAdvance = 17;
    }

    return static_cast<int16_t>(length * charAdvance);
}
